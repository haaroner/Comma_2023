# Keil uVision project aaa.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aaa
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,STM32F40_41xxx, USE_STDPERIPH_DRIVER,  HSE_VALUE = 8000000, USE_HSE
  c include: .\src\main;.\src\external;.\src\spl4;.\src\global_macros;.\src\spl4\inc;.\src\spl4\src;.\src\support_pacage\inc;.\src\support_pacage\arm;.\src\support_pacage\gcc;.\src\support_pacage\gcc\linker;.\src\support_pacage;.\src\cmsis;.\src\OpenMV;.\src\pin_setup;.\src\motor;.\src\motors;.\src\IRLocator;.\src\time_service;.\src\kicker;.\src\i2c;.\src\SPI;.\src\ball_detour;.\src\UART;.\src\robot_math;.\src\dribler;.\src\adc;.\src\dma;.\src\main;.\src\voltmeter;.\src\mpu9250_spi;.\src\SPI_DOT;.\src\UART\usart2;.\src\UART\usart3;.\src\UART\usart6;.\src\Robot;..\Comma_2023_open;.\src\TSSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: main.cpp Settings.h tools.cpp
    ./src/main/: project_config.h RTE_Device.h startup_stm32f407xx.s retarget.cpp libs.h tools.h
    ./src/support_pacage/: system_stm32f4xx.c
  group Robot
    ./src/Robot/: Robot.h
  group Maths
    ./src/ball_detour/: ball_detour.h
    ./src/robot_math/: robot_math.h points_movement.h Timers.h PID.h
  group pins
    ./src/pin_setup/: pin_setup.h pin_setup.cpp
  group time_service
    ./src/time_service/: time_service.h time_service.cpp
  group UART
    ./src/UART/usart2/: uart2.cpp usart2.h
    ./src/UART/usart3/: usart3.h usart3.cpp
    ./src/UART/usart6/: usart6.h usart6.cpp
  group SPI
    ./src/SPI/: SPI.h
    ./src/SPI/SPI_1/: SPI_1.h SPI_1.cpp
    ./src/SPI/SPI_2/: SPI_2.h SPI_2.cpp
    ./src/SPI/SPI_3/: SPI_3.h SPI_3.cpp
  group i2c
    ./src/i2c/: soft_i2c.cpp soft_i2c.h
  group ADC
    ./src/adc/: adc.h adc.cpp
  group DMA
    ./src/dma/: dma.h dma.cpp
  group motor
    ./src/motor/: motor.h motor.cpp
  group motors
    ./src/motors/: motors.h motors.cpp
  group OpenMv
    ./src/OpenMV/: OpenMV.h OpenMV.cpp
  group MPU9250_spi
    ./src/mpu9250_spi/: mpu9250_spi.cpp mpu9250_spi.h mpu9250_registers_spi.h IMU_SPI.h
  group voltmeter
    ./src/voltmeter/: voltmeter.h voltmeter.cpp
  group dribler
    ./src/dribler/: dribler.h dribler.cpp
  group line
    ./src/line/: line.h line.cpp
  group SPI_DOT
    ./src/SPI_DOT/: SPI2_DOT.h
    ./: SPI_DOT.cpp
  group IRLocator360
    ./src/IRLocator/: IRLocator.h IRLocator.cpp
  group kicker
    ./src/kicker/: kicker.h kicker.cpp
  group bluetooth
    ./src/bluetooth/hc-05/: hc-05.h
  group TSSP
    ./src/TSSP/: TSSP.h TSSP.cpp
  group spl4
    ./src/spl4/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
    ./src/spl4/: stm32f4xx_conf.h
